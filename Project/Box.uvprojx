# Keil uVision project Box.uvprojx, settings and files
target Box (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: Box +hex
  c flags: Optim=1
  c define: NRF51
  c include: ..\LIB\Include;..\LIB\Include\boards;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../User/: main.c
  group LIB
    ../LIB/Source/simple_uart/: simple_uart.c
    ../LIB/Source/nrf_delay/: nrf_delay.c
    ../User/: mma8451.c ad7151.c
    ../LIB/Source/twi_master/: twi_hw_master.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
